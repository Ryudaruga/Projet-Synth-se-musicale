# Keil uVision project Projet_V3.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Projet_V3
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.0, Board Support:A/D Converter 2.0.0, Board Support:LED 2.0.0, CMSIS Driver:USART 2.11, Device:STM32Cube Framework:Classic 1.2.7, Device:STM32Cube HAL:ADC 1.2.7, Device:STM32Cube HAL:Common 1.2.7, Device:STM32Cube HAL:Cortex 1.2.7, Device:STM32Cube HAL:DAC 1.2.7, Device:STM32Cube HAL:DMA 1.2.7, Device:STM32Cube HAL:GPIO 1.2.7, Device:STM32Cube HAL:RCC 1.2.7, Device:STM32Cube HAL:RTC 1.2.7, Device:STM32Cube HAL:TIM 1.2.7, Device:STM32Cube HAL:USART 1.2.7, Device:Startup 2.2.1
